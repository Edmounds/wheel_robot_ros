Commit message: update

File: src/sim/urdf/two_wheel_diff_robot.urdf (robot description, URDF)
Before this commit: robot two_wheel_diff_robot, 7 links, 6 joints
Joints:
- joint laser_joint: origin xyz=0.14 0 0.16 rpy=0 0 0 -> xyz=-0.063138 0 0 rpy=3.14159265359 0 3.14159265359
